# Keil uVision project SMKCODEACADEMY.uvprojx, settings and files
target SMKCODEACADEMY (5060528::V5.06 update 5 (build 528)::.\ARMCC)
  device: STM32F767ZITx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.15.1
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: SMKCODEACADEMY +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F767xx
  c include: ../Core/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../Custom_Code/C_Defines;../Custom_Code/C_typedef;../Custom_Code/ELECTRICAL;../Custom_Code/FSM;../Simulink_Code/External;../Simulink_Code/Models/_sharedutils;../Simulink_Code/Models/CircuitInterface;../Simulink_Code/Models/FSM;../Simulink_Code/SMKCODEACADEMY
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32f767xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c eth.c usart.c usb_otg.c stm32f7xx_it.c stm32f7xx_hal_msp.c stm32f7xx_hal_timebase_tim.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_cortex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_eth.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
  group Application/Custom
    ../Custom_Code/ELECTRICAL/: ELECTRICAL_module.c
  group Application/Simulink/External
    ../Simulink_Code/External/: ex_2bb3e2ac.c ex_2cdf97d7.c ex_2ebcd5b2.c ex_04d5441d.c ex_06bcd123.c ex_6dd8e72d.c ex_6dd531e9.c ex_7cd25341.c ex_7d002618.c ex_8a6fc761.c ex_8ebb89cc.c ex_17bc61ac.c ex_18b4440a.c ex_40d5be33.c ex_45d28653.c ex_47b11894.c ex_47b17260.c ex_53bcffa7.c ex_60b4e4f8.c ex_76dd91b2.c ex_79d100f1.c ex_81be18a2.c ex_98d223a6.c ex_316a8f13.c ex_316a81de.c ex_440d4aba.c ex_690b7cd0.c ex_36012fa7.c ex_50027bf1.c ex_136645f8.c ex_57660158.c ex_a1dafa44.c ex_acbcf277.c ex_aed5de1e.c ex_b2b40ad5.c ex_bb0efd4b.c ex_c9069dae.c ex_d9d686a8.c ex_debffef2.c ex_e10a4cd8.c ex_e40d74b8.c ex_eb0d559b.c ex_f6bb4c2d.c ex_f9b702ea.c ex_f26168b3.c ex_f866102d.c ex_f7688368.c mc_0bd30dee.c mc_0d6fd085.c mc_0ed73c49.c mc_0edc34e3.c mc_2a6a9b24.c mc_2a6b417d.c mc_2a642f54.c mc_2bbf87e3.c mc_2cdc96b4.c mc_03b98f6f.c mc_3b6a945d.c mc_3e66abdf.c mc_4b0301c6.c mc_4c6117e3.c mc_5bd2c9c1.c mc_5d65cd86.c mc_5edd42ef.c mc_6b6d311a.c mc_6e61d16c.c mc_6fb1c336.c mc_7a613aec.c mc_7bbf41f0.c mc_7cd58f0b.c mc_7cdbe436.c mc_7d099de7.c mc_7d0547c8.c mc_7eb21b39.c mc_9ab7d9b0.c mc_9b6c1529.c mc_9b6376d1.c mc_10d4ab75.c mc_15d12d95.c mc_15d828ca.c mc_026e4f4b.c mc_32d501e3.c mc_32dc008a.c mc_47b8cebe.c mc_47b91db1.c mc_51d4094e.c mc_53b1fc84.c mc_53b6fcf3.c mc_59b6e413.c mc_67da4f41.c mc_67da200d.c mc_81b0ada5.c mc_81b5717e.c mc_84b5f9fb.c mc_89d597cf.c mc_90b6aa0a.c mc_95b62b73.c mc_110e6c6c.c mc_140e3c4c.c mc_220ba961.c mc_630dda0e.c mc_870ec75e.c mc_1407e917.c mc_2565d6e0.c mc_7207b6f4.c mc_7809a65c.c mc_52688a58.c mc_550847c3.c mc_630208f8.c mc_0764157d.c mc_4105189f.c mc_5766048f.c mc_11086079.c mc_52623861.c mc_a00e5f46.c mc_a3b90582.c mc_a6b5ed24.c mc_a26bab1a.c mc_a865d1dd.c mc_a2647600.c mc_a7684938.c mc_acb3fad7.c mc_af0bc203.c mc_af0cc4c9.c mc_b0de9cbc.c mc_b2b86ae3.c mc_b7b03d44.c mc_b96a0bad.c mc_b362c5eb.c mc_bb0520ee.c mc_bdbb9b78.c mc_c2dbf4b2.c mc_c7de7352.c mc_c8d25d23.c mc_cab8a1f9.c mc_ce6656ce.c mc_d9d38185.c mc_d20085b7.c mc_dbbb14d2.c mc_dcdddfae.c mc_debb448f.c mc_e7b99cf6.c mc_e7bc2f1a.c mc_e969ae87.c mc_e9661c4a.c mc_edbf543c.c mc_ee000fbe.c mc_efdea3a7.c mc_f00d2f9b.c mc_f3be157c.c mc_f0012953.c mc_fbd54145.c mc_fcb15a9b.c mc_fd619d14.c mc_fd6341bb.c pm_4fd5f5b9.c pm_09bc42e2.c pm_9dd7a82d.c pm_26dc3230.c pm_14098e54.c pm_fed8c2c9.c ssc_core_0bd666aa.c ssc_core_0d65be6c.c ssc_core_0f019bd9.c ssc_core_0f0420a6.c ssc_core_01dcc633.c ssc_core_1c6b0332.c ssc_core_1fd25120.c ssc_core_2cd54448.c ssc_core_04da2c69.c ssc_core_4ad9135b.c ssc_core_4db6bd68.c ssc_core_4db86fcc.c ssc_core_4e03e39d.c ssc_core_4e04eecd.c ssc_core_4e06e3bd.c ssc_core_5a046b27.c ssc_core_5d6ba758.c ssc_core_06ba68a6.c ssc_core_6b6b89d2.c ssc_core_6b663a17.c ssc_core_6dd833f3.c ssc_core_7a613edb.c ssc_core_8a6471dc.c ssc_core_8cd9cb37.c ssc_core_8d0064b8.c ssc_core_09b5fa6e.c ssc_core_9b607b15.c ssc_core_9b671e57.c ssc_core_9c01d168.c ssc_core_9c016445.c ssc_core_9dd110ad.c ssc_core_9fb0e229.c ssc_core_9fb2e56c.c ssc_core_9fb25b4f.c ssc_core_18bf4d77.c ssc_core_24b4cdee.c ssc_core_32d8b307.c ssc_core_37d4ea84.c ssc_core_40db642d.c ssc_core_40dfdbdc.c ssc_core_48b1386a.c ssc_core_54d55ae9.c ssc_core_56b1a2bf.c ssc_core_59b034b8.c ssc_core_67d1f118.c ssc_core_68da074b.c ssc_core_73d9c2b7.c ssc_core_76d825be.c ssc_core_83db8762.c ssc_core_89d7fa79.c ssc_core_280c0222.c ssc_core_360a4baf.c ssc_core_550b4c41.c ssc_core_576cd129.c ssc_core_770cead7.c ssc_core_990fe1a4.c ssc_core_3169e4b7.c ssc_core_3306c008.c ssc_core_4666b45b.c ssc_core_05058dd9.c ssc_core_7209d3a5.c ssc_core_8569edc5.c ssc_core_856738f2.c ssc_core_5505224d.c ssc_core_41017299.c ssc_core_96061071.c ssc_core_a1d393be.c ssc_core_a4d4c45e.c ssc_core_a4da1d0a.c ssc_core_a6b78ccc.c ssc_core_a9bbaecc.c ssc_core_a9bf1ff2.c ssc_core_a269ab09.c ssc_core_a867d880.c ssc_core_a76299bc.c ssc_core_aa09f23c.c ssc_core_abd05c18.c ssc_core_abd5e7b4.c ssc_core_acb6462e.c ssc_core_acb64294.c ssc_core_b2b3b239.c ssc_core_b7b88213.c ssc_core_b10e34f4.c ssc_core_b96ebc21.c ssc_core_b369cd13.c ssc_core_b402b40d.c ssc_core_b1038cbb.c ssc_core_bad68669.c ssc_core_bc648043.c ssc_core_bfdb08db.c ssc_core_c5b050d7.c ssc_core_c5b63cb2.c ssc_core_c8d83e88.c ssc_core_c607b660.c ssc_core_c3003040.c ssc_core_cab615c8.c ssc_core_cabdc251.c ssc_core_cc0bcab0.c ssc_core_cc067f58.c ssc_core_ce6a84bb.c ssc_core_d3d34d7c.c ssc_core_d4b9397b.c ssc_core_d06d763c.c ssc_core_d70a6a09.c ssc_core_d807fa59.c ssc_core_dcda6edd.c ssc_core_deb7fd8d.c ssc_core_e0d0866d.c ssc_core_e2b61d72.c ssc_core_e400c1c2.c ssc_core_ead8f455.c ssc_core_edb836de.c ssc_core_ee000fbe.c ssc_core_ee0f0141.c ssc_core_ee01086d.c ssc_core_f9b6dbed.c ssc_core_fa09e9e6.c ssc_core_fbd34e62.c ssc_core_ff06d9a4.c ssc_sli_0bd269e6.c ssc_sli_0d6d0780.c ssc_sli_1c690f90.c ssc_sli_1db813e8.c ssc_sli_2bbd58a4.c ssc_sli_2f6ea1cd.c ssc_sli_3fb4607e.c ssc_sli_4e028390.c ssc_sli_5a0cb974.c ssc_sli_5d63aeeb.c ssc_sli_7a618260.c ssc_sli_7f65db03.c ssc_sli_8a64c4e2.c ssc_sli_9abcdb7f.c ssc_sli_9b67747c.c ssc_sli_9c030181.c ssc_sli_15d5f6ce.c ssc_sli_37d957ac.c ssc_sli_40d56d93.c ssc_sli_42b14021.c ssc_sli_62d81790.c ssc_sli_89d0f30a.c ssc_sli_136b443c.c ssc_sli_136f97a1.c ssc_sli_140b3534.c ssc_sli_256cd4b6.c ssc_sli_360cfd63.c ssc_sli_466b08dd.c ssc_sli_550a4805.c ssc_sli_0763c151.c ssc_sli_880e593a.c ssc_sli_77063d8b.c ssc_sli_93019ea6.c ssc_sli_0267402d.c ssc_sli_496799bd.c ssc_sli_6305062f.c ssc_sli_43618287.c ssc_sli_c7dda239.c ssc_sli_d064c978.c ssc_sli_d80c44d2.c ssc_sli_dcd66f69.c ssc_sli_e7b327bb.c ssc_sli_e66fe6d5.c ssc_sli_eb0a5702.c ssc_sli_edbee55c.c ssc_sli_f6bd9cc8.c ssc_sli_f9b5dbc5.c ssc_sli_fa0ce53e.c ssc_sli_fbdf29da.c ssc_st_7f64b2fa.c ssc_st_12be8102.c ssc_st_59ba8c5e.c ssc_st_65b906f8.c ssc_st_870f70cf.c ssc_st_43603aca.c ssc_st_a3b260e9.c ssc_st_a868d115.c ssc_st_a7639c45.c ssc_st_d56af4a2.c
  group Application/Simulink/Models/Circuit
    ../Simulink_Code/Models/CircuitInterface/: CircuitInterface.c CircuitInterface_dcd86948_1.c CircuitInterface_dcd86948_1_ds.c CircuitInterface_dcd86948_1_ds_log.c CircuitInterface_dcd86948_1_ds_obs_act.c CircuitInterface_dcd86948_1_ds_obs_all.c CircuitInterface_dcd86948_1_ds_obs_exp.c CircuitInterface_dcd86948_1_ds_obs_il.c CircuitInterface_dcd86948_1_gateway.c
  group Application/Simulink/Models/FSM
    ../Simulink_Code/Models/FSM/: FSM.c
  group Application/Simulink/Models/Shared
    ../Simulink_Code/Models/_sharedutils/: rt_backsubrr_dbl.c rt_forwardsubrr_dbl.c rt_lu_real.c rt_matrixlib_dbl.c rt_nonfinite.c rtGetInf.c rtGetNaN.c
  group Application/Simulink/MainModel
    ../Simulink_Code/SMKCODEACADEMY/: rtmodel.c SMKCODEACADEMY.c
  group Application/Data
    ../Custom_Code/C_typedef/: GLOBAL.c
software components: CMSIS:CORE 4.3.0
